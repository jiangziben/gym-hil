Commit message: Fix:1.增加末端力传感器,修复urdf中末端力碰撞的bug

File: gym_hil/assets/auboc5/urdf/aubo_C5.urdf (robot description, URDF)
Before this commit: robot aubo_C5, 13 links, 12 joints
Joints:
- joint charging_gun_joint: origin xyz=0.0 0.0 0.13 rpy=-1.57 -1.57 0 -> xyz=0.0 0.0 0.131 rpy=-1.57 -1.57 0
